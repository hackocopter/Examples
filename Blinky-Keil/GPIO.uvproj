# Keil uVision project GPIO.uvproj, settings and files
target GPIO (ARM-ADS)
  device: M0516LAN Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0xFFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: GPIO
  AfterMake: fromelf --bin ".\output\@L.axf" --output ".\output\@L.bin"
  AfterMake: fromelf --text -c ".\output\@L.axf" --output ".\output\@L.txt"
  c flags: Optim=1
  c include: ..\..\Include
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group Source
    ./Source/: GPIO_Demo.c
  group Common
    ../../Common/: common.c startup_M051.s
