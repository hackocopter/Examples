# Keil uVision project GPIO.uvproj, settings and files
target GPIO (ARM-ADS)
  device: Mini54ZAN Nuvoton
  cpu: IRAM(0x20000000-0x200007FF) IROM(0-0x3FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: GPIO +hex
  AfterMake: fromelf --bin ".\output\@L.axf" --output ".\output\@L.bin"
  AfterMake: fromelf --text -c ".\output\@L.axf" --output ".\output\@L.txt"
  c flags: Optim=3
  c include: .\Include
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x800
  group Source
    ./Source/: GPIO_Demo.c
  group Common
    ./Common/: common.c startup_M051.s
